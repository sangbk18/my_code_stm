# Keil uVision project RTOS.uvprojx, settings and files
target RTOS_SANG (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c my_assembly.s MY_RTOS.h MY_RTOS.c my_diver_stm32f1xx.h my_driver_stm32f1xx.c My_application_stm32f1xx.h My_application_stm32f1xx.c My_sensors_lib.h My_sensors_lib.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
